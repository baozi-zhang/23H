# Keil uVision project zuolan_STM32.uvprojx, settings and files
target zuolan_STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ../Core/Inc;                   ../Drivers/STM32F4xx_HAL_Driver/Inc;                   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                   ../Drivers/CMSIS/Include;                   ../MY_Algorithms/Inc;                   ../MY_Communication/Inc;                   ../MY_Hardware_Drivers/Inc;                   ../MY_Utilities/Inc;                   ..\MY_APP;                   ..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c fmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group MY_Hardware_Drivers
    ../MY_Hardware_Drivers/Src/: ad_measure.c AD9959.c da_output.c freq_measure.c key_app.c
  group MY_Algorithms
    ../MY_Algorithms/Src/: my_fft.c my_filter.c phase_measure.c kalman.c
    ../MY_Algorithms/Inc/: kalman.h
  group MY_Communication
    ../MY_Communication/Src/: my_hmi.c my_usart.c my_usart_pack.c
  group MY_Utilities
    ../MY_Utilities/Src/: cmd_to_fun.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group MY_APP
    ../MY_APP/: scheduler.c scheduler.h bsp_system.h app_pid.c app_pid.h stm_sig.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.4.0
